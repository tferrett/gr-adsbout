options:
  parameters:
    generate_options: qt_gui
    id: hackrf_tx
    output_language: python
    title: HackRF Tx Flowgraph
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 1090e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '40'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2e6)
  states: {}
- name: adsbout_adsb_Concentrator_0
  id: adsbout_adsb_Concentrator
  parameters:
    gap: '995640'
    ninputs: '2'
  states: {}
- name: adsbout_adsb_ident_source_0
  id: adsbout_adsb_ident_source
  parameters:
    callsign: ROFL12
    ec: '3'
    icao: '0x666888'
  states: {}
- name: adsbout_adsb_position_source_2
  id: adsbout_adsb_position_source
  parameters:
    altitude: '9876.4'
    capability: '5'
    icao: '0x666888'
    intermessagegap: '99564'
    latitude: '33.841186'
    longitude: '-118.403249'
    nicsupplementb: '0'
    surface: 'False'
    surveillancestatus: '0'
    time: '0'
    typecode: '11'
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '20'
    freq0: freq
    gain0: '11'
    if_gain0: gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [adsbout_adsb_Concentrator_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [adsbout_adsb_ident_source_0, '0', adsbout_adsb_Concentrator_0, '1']
- [adsbout_adsb_position_source_2, '0', adsbout_adsb_Concentrator_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
