options:
  parameters:
    generate_options: qt_gui
    id: untitled2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 1090e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: '30'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2e6)
  states: {}
- name: adsbout_adsb_Concentrator_0
  id: adsbout_adsb_Concentrator
  parameters:
    gap: '995640'
    ninputs: '4'
  states: {}
- name: adsbout_adsb_ident_source_0
  id: adsbout_adsb_ident_source
  parameters:
    callsign: AB123
    ec: '3'
    icao: '0x666888'
  states: {}
- name: adsbout_adsb_ident_source_1
  id: adsbout_adsb_ident_source
  parameters:
    callsign: CC1234
    ec: '3'
    icao: '0x666777'
  states: {}
- name: adsbout_adsb_position_source_2
  id: adsbout_adsb_position_source
  parameters:
    altitude: '9876.4'
    capability: '5'
    icao: '0x666888'
    intermessagegap: '99564'
    latitude: '40.0773267203'
    longitude: '116.6003801203'
    nicsupplementb: '0'
    surface: 'False'
    surveillancestatus: '0'
    time: '0'
    typecode: '11'
  states: {}
- name: adsbout_adsb_position_source_2_0
  id: adsbout_adsb_position_source
  parameters:
    altitude: '19876.4'
    capability: '5'
    icao: '0x666777'
    intermessagegap: '99564'
    latitude: '40.0773267201'
    longitude: '116.6003801201'
    nicsupplementb: '0'
    surface: 'False'
    surveillancestatus: '0'
    time: '0'
    typecode: '11'
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    dev_args: '""'
    gain0: gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}

connections:
- [adsbout_adsb_Concentrator_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [adsbout_adsb_ident_source_0, '0', adsbout_adsb_Concentrator_0, '2']
- [adsbout_adsb_ident_source_1, '0', adsbout_adsb_Concentrator_0, '3']
- [adsbout_adsb_position_source_2, '0', adsbout_adsb_Concentrator_0, '0']
- [adsbout_adsb_position_source_2_0, '0', adsbout_adsb_Concentrator_0, '1']
- [blocks_interleaved_char_to_complex_0, '0', qtgui_sink_x_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
